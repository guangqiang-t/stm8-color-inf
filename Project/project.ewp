# IAR project project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S208C8 STM8S208C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S207; USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: ..\Libraries\STM8S_StdPeriph_Driver\inc; ..\Libraries\STM8S_StdPeriph_Driver\src; ..\Conf; ..\Bsp; ..\User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s208c8.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG; STM8S207
  group Bsp
    ../Bsp/: bsp_audio.c bsp_color.c bsp_delay.c bsp_led.c bsp_uart.c
  group Cfg
    ../Conf/: stm8s_it.c stm8s_it.h
  group Libraries
    ../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim3.c stm8s_uart1.c
    ../Conf/: stm8s_conf.h
  group User
    ../User/: main.c
